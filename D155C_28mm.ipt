# Autodesk Inventor part: D155C_28mm
## iProperties
Created: 2011-03
Part Number: D155C_28mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
